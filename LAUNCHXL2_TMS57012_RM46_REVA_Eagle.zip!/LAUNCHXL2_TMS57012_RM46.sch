# EAGLE board LAUNCHXL2_TMS57012_RM46 (EAGLE 7.1.0), part 1 of 2

Size 130.81 x 67.31 mm. Coordinates in mm from the lower left corner, seen from the top.
Outline: 0,0 130.81,0 130.81,67.31 0,67.31 0,0
Copper layers (1+2+15+16): Top 0.034290625mm / dielectric 0.23621875mm / Route2 0.034290625mm / dielectric 39mil / Route15 0.034290625mm / dielectric 0.24891875mm / Bottom 0.034290625mm
Design rules "lp_proto-6Lyr *": minimum track width 6mil, minimum drill 15mil, track to track 6mil, track to pad 6mil, pad to pad 6mil, via to via 6mil, smd to smd 6mil, copper to edge 25mil, drill to drill 16mil, minimum pad ring 10mil, minimum via ring 6mil, stop-mask expansion 2.5mil, vias tented up to drill 20mil, thermal gap 10mil
Net classes: 0 default: width 0.152 mm, drill 0.381 mm; 1 USBD: width 0.356 mm, drill 0.381 mm, clearance 0.152 mm to class 0, clearance 0.152 mm

## Footprints (pad centres in the part's own frame; a part is rotated, then mirrored left to right if it is on the bottom)
1,6/0,9 = drill 0.914 pad 1.6 octagon: 1 0,0
C0402K = smd 0.925 x 0.74: 1 -0.6,0; 2 0.6,0
C0402 = smd 0.7 x 0.9: 1 -0.65,0; 2 0.65,0
C0805K = smd 1.3 x 1.6: 1 -1,0; 2 1,0
C0603K = smd 1.05 x 1.08: 1 -0.875,0; 2 0.875,0
C1206K = smd 1.5 x 2: 1 -1.5,0; 2 1.5,0
FB_MJ4516 = smd 1.75 x 2: 1 -1.875,0; 2 1.875,0
FIDUCIAL_1MM = smd 1 x 1: 1 0,0
SAMTEC-FTR-110-51-S-D-06 = smd 0.711 x 2.87: 1 -5.715,-2.682; 2 -5.715,2.682; 3 -4.445,-2.682; 4 -4.445,2.682; 5 -3.175,-2.682; 6 -3.175,2.682; 7 -1.905,-2.682; 8 -1.905,2.682; 9 -0.635,-2.682; 10 -0.635,2.682; 11 0.635,-2.682; 12 0.635,2.682; 13 1.905,-2.682; 14 1.905,2.682; 15 3.175,-2.682; 16 3.175,2.682; 17 4.445,-2.682; 18 4.445,2.682; 19 5.715,-2.682; 20 5.715,2.682 | drill 1.321: M1 -5.08,0; M2 5.08,0
1X10 = drill 1.016 square: 1 -11.43,0 | drill 1.016: 2 -8.89,0; 3 -6.35,0; 4 -3.81,0; 5 -1.27,0; 6 1.27,0; 7 3.81,0; 8 6.35,0; 9 8.89,0; 10 11.43,0
1X50_ALT = drill 1.016 square: 1 -62.23,0; 11 -36.83,0; 21 -11.43,0; 31 13.97,0; 41 39.37,0 | drill 1.016: 2 -59.69,0; 3 -57.15,0; 4 -54.61,0; 5 -52.07,0; 6 -49.53,0; 7 -46.99,0; 8 -44.45,0; 9 -41.91,0; 10 -39.37,0; 12 -34.29,0; 13 -31.75,0; 14 -29.21,0; 15 -26.67,0; 16 -24.13,0; 17 -21.59,0; 18 -19.05,0; 19 -16.51,0; 20 -13.97,0; 22 -8.89,0; 23 -6.35,0; 24 -3.81,0; 25 -1.27,0; 26 1.27,0; 27 3.81,0; 28 6.35,0; 29 8.89,0; 30 11.43,0; 32 16.51,0; 33 19.05,0; 34 21.59,0; 35 24.13,0; 36 26.67,0; 37 29.21,0; 38 31.75,0; 39 34.29,0; 40 36.83,0; 42 41.91,0; 43 44.45,0; 44 46.99,0; 45 49.53,0; 46 52.07,0; 47 54.61,0; 48 57.15,0; 49 59.69,0; 50 62.23,0
1X50 = drill 1.016 square: 1 -62.23,0; 11 -36.83,0; 21 -11.43,0; 31 13.97,0; 41 39.37,0 | drill 1.016: 2 -59.69,0; 3 -57.15,0; 4 -54.61,0; 5 -52.07,0; 6 -49.53,0; 7 -46.99,0; 8 -44.45,0; 9 -41.91,0; 10 -39.37,0; 12 -34.29,0; 13 -31.75,0; 14 -29.21,0; 15 -26.67,0; 16 -24.13,0; 17 -21.59,0; 18 -19.05,0; 19 -16.51,0; 20 -13.97,0; 22 -8.89,0; 23 -6.35,0; 24 -3.81,0; 25 -1.27,0; 26 1.27,0; 27 3.81,0; 28 6.35,0; 29 8.89,0; 30 11.43,0; 32 16.51,0; 33 19.05,0; 34 21.59,0; 35 24.13,0; 36 26.67,0; 37 29.21,0; 38 31.75,0; 39 34.29,0; 40 36.83,0; 42 41.91,0; 43 44.45,0; 44 46.99,0; 45 49.53,0; 46 52.07,0; 47 54.61,0; 48 57.15,0; 49 59.69,0; 50 62.23,0
FTSH-105-01-F-DV = smd 0.737 x 2.794: 1 -2.54,-2.032; 2 -2.54,2.032; 3 -1.27,-2.032; 4 -1.27,2.032; 5 0,-2.032; 6 0,2.032; 7 1.27,-2.032; 8 1.27,2.032; 9 2.54,-2.032; 10 2.54,2.032
USB_MICRO_B_SMD = smd 0.4 x 1.4: 1 -1.3,2.65; 2 -0.65,2.65; 3 0,2.65; 4 0.65,2.65; 5 1.3,2.65 | smd 2 x 2.1: S1 -3,2.3; S2 3,2.3 | smd 2.6 x 1.9: S3 -3.7,0; S4 3.7,0 | smd 1.5 x 1.5: S5 -1,0; S6 1,0
CUI_PJ002BH = smd 2.8 x 2.4: 1A -2.4,5.7; 1B 3.7,5.7; 2 -2.4,-5.7; 3 3.7,-5.7 | drill 1.6: P$3 -2.4,0 | drill 1.8: P$4 2.1,0
JP1 = drill 1.016 square: 1 0,-1.27 | drill 1.016: 2 0,1.27
L2520P = smd 0.9 x 2.2: 1 -1.045,0; 2 1.045,0
CHIPLED_0603 = smd 0.8 x 0.8: A 0,-0.75; C 0,0.75
MH_94_200 = drill 2.388 pad 5.08: 1 0,0
2,54/1,1 = drill 1.016 pad 2.54 octagon: 1 0,0
SMD1,27-2,54 = smd 1.27 x 1.27: 1 0,0
TEMT6000 = smd 1.1 x 0.8: 1 -3.5,0.55; 2 -3.5,-0.55 | smd 1.1 x 1: 3 0,0
R0402 = smd 0.7 x 0.9: 1 -0.65,0; 2 0.65,0
R1206W = smd 1.8 x 1.2: 1 -1.499,0; 2 1.499,0
CK_PTS645_SMD = smd 1.55 x 1.3: 1 -3.975,2.25; 2 3.975,2.25; 3 -3.975,-2.25; 4 3.975,-2.25
PGE144 = smd 1.473 x 0.267: 1 -10.719,8.738; 2 -10.719,8.255; 3 -10.719,7.747; 4 -10.719,7.239; 5 -10.719,6.756; 6 -10.719,6.248; 7 -10.719,5.74; 8 -10.719,5.258; 9 -10.719,4.75; 10 -10.719,4.242; 11 -10.719,3.759; 12 -10.719,3.251; 13 -10.719,2.743; 14 -10.719,2.261; 15 -10.719,1.753; 16 -10.719,1.245; 17 -10.719,0.762; 18 -10.719,0.254; 19 -10.719,-0.254; 20 -10.719,-0.762; 21 -10.719,-1.245; 22 -10.719,-1.753; 23 -10.719,-2.261; 24 -10.719,-2.743; 25 -10.719,-3.251; 26 -10.719,-3.759; 27 -10.719,-4.242; 28 -10.719,-4.75; 29 -10.719,-5.258; 30 -10.719,-5.74; 31 -10.719,-6.248; 32 -10.719,-6.756; 33 -10.719,-7.239; 34 -10.719,-7.747; 35 -10.719,-8.255; 36 -10.719,-8.738; 73 10.719,-8.738; 74 10.719,-8.255; 75 10.719,-7.747; 76 10.719,-7.239; 77 10.719,-6.756; 78 10.719,-6.248; 79 10.719,-5.74; 80 10.719,-5.258; 81 10.719,-4.75; 82 10.719,-4.242; 83 10.719,-3.759; 84 10.719,-3.251; 85 10.719,-2.743; 86 10.719,-2.261; 87 10.719,-1.753; 88 10.719,-1.245; 89 10.719,-0.762; 90 10.719,-0.254; 91 10.719,0.254; 92 10.719,0.762; 93 10.719,1.245; 94 10.719,1.753; 95 10.719,2.261; 96 10.719,2.743; 97 10.719,3.251; 98 10.719,3.759; 99 10.719,4.242; 100 10.719,4.75; 101 10.719,5.258; 102 10.719,5.74; 103 10.719,6.248; 104 10.719,6.756; 105 10.719,7.239; 106 10.719,7.747; 107 10.719,8.255; 108 10.719,8.738 | smd 0.267 x 1.473: 37 -8.738,-10.719; 38 -8.255,-10.719; 39 -7.747,-10.719; 40 -7.239,-10.719; 41 -6.756,-10.719; 42 -6.248,-10.719; 43 -5.74,-10.719; 44 -5.258,-10.719; 45 -4.75,-10.719; 46 -4.242,-10.719; 47 -3.759,-10.719; 48 -3.251,-10.719; 49 -2.743,-10.719; 50 -2.261,-10.719; 51 -1.753,-10.719; 52 -1.245,-10.719; 53 -0.762,-10.719; 54 -0.254,-10.719; 55 0.254,-10.719; 56 0.762,-10.719; 57 1.245,-10.719; 58 1.753,-10.719; 59 2.261,-10.719; 60 2.743,-10.719; 61 3.251,-10.719; 62 3.759,-10.719; 63 4.242,-10.719; 64 4.75,-10.719; 65 5.258,-10.719; 66 5.74,-10.719; 67 6.248,-10.719; 68 6.756,-10.719; 69 7.239,-10.719; 70 7.747,-10.719; 71 8.255,-10.719; 72 8.738,-10.719; 109 8.738,10.719; 110 8.255,10.719; 111 7.747,10.719; 112 7.239,10.719; 113 6.756,10.719; 114 6.248,10.719; 115 5.74,10.719; 116 5.258,10.719; 117 4.75,10.719; 118 4.242,10.719; 119 3.759,10.719; 120 3.251,10.719; 121 2.743,10.719; 122 2.261,10.719; 123 1.753,10.719; 124 1.245,10.719; 125 0.762,10.719; 126 0.254,10.719; 127 -0.254,10.719; 128 -0.762,10.719; 129 -1.245,10.719; 130 -1.753,10.719; 131 -2.261,10.719; 132 -2.743,10.719; 133 -3.251,10.719; 134 -3.759,10.719; 135 -4.242,10.719; 136 -4.75,10.719; 137 -5.258,10.719; 138 -5.74,10.719; 139 -6.248,10.719; 140 -6.756,10.719; 141 -7.239,10.719; 142 -7.747,10.719; 143 -8.255,10.719; 144 -8.738,10.719
DBV6 = smd 1.473 x 0.559: 1 -1.118,0.94; 2 -1.118,0; 3 -1.118,-0.94; 4 1.118,-0.94; 5 1.118,0; 6 1.118,0.94
MXA20A = smd 1.422 x 0.356: 1 -2.845,2.921; 2 -2.845,2.286; 3 -2.845,1.626; 4 -2.845,0.965; 5 -2.845,0.33; 6 -2.845,-0.33; 7 -2.845,-0.965; 8 -2.845,-1.626; 9 -2.845,-2.286; 10 -2.845,-2.921; 11 2.845,-2.921; 12 2.845,-2.286; 13 2.845,-1.626; 14 2.845,-0.965; 15 2.845,-0.33; 16 2.845,0.33; 17 2.845,0.965; 18 2.845,1.626; 19 2.845,2.286; 20 2.845,2.921 | smd 3.15 x 4.343: 21 0,0
DCK6 = smd 1.168 x 0.356: 1 -0.965,0.66; 2 -0.965,0; 3 -0.965,-0.66; 4 0.965,-0.66; 5 0.965,0; 6 0.965,0.66
PDT128 = smd 1.575 x 0.191: 1 -7.62,6.198; 2 -7.62,5.791; 3 -7.62,5.41; 4 -7.62,5.004; 5 -7.62,4.597; 6 -7.62,4.191; 7 -7.62,3.81; 8 -7.62,3.404; 9 -7.62,2.997; 10 -7.62,2.591; 11 -7.62,2.21; 12 -7.62,1.803; 13 -7.62,1.397; 14 -7.62,0.991; 15 -7.62,0.61; 16 -7.62,0.203; 17 -7.62,-0.203; 18 -7.62,-0.61; 19 -7.62,-0.991; 20 -7.62,-1.397; 21 -7.62,-1.803; 22 -7.62,-2.21; 23 -7.62,-2.591; 24 -7.62,-2.997; 25 -7.62,-3.404; 26 -7.62,-3.81; 27 -7.62,-4.191; 28 -7.62,-4.597; 29 -7.62,-5.004; 30 -7.62,-5.41; 31 -7.62,-5.791; 32 -7.62,-6.198; 65 7.62,-6.198; 66 7.62,-5.791; 67 7.62,-5.41; 68 7.62,-5.004; 69 7.62,-4.597; 70 7.62,-4.191; 71 7.62,-3.81; 72 7.62,-3.404; 73 7.62,-2.997; 74 7.62,-2.591; 75 7.62,-2.21; 76 7.62,-1.803; 77 7.62,-1.397; 78 7.62,-0.991; 79 7.62,-0.61; 80 7.62,-0.203; 81 7.62,0.203; 82 7.62,0.61; 83 7.62,0.991; 84 7.62,1.397; 85 7.62,1.803; 86 7.62,2.21; 87 7.62,2.591; 88 7.62,2.997; 89 7.62,3.404; 90 7.62,3.81; 91 7.62,4.191; 92 7.62,4.597; 93 7.62,5.004; 94 7.62,5.41; 95 7.62,5.791; 96 7.62,6.198 | smd 0.191 x 1.575: 33 -6.198,-7.62; 34 -5.791,-7.62; 35 -5.41,-7.62; 36 -5.004,-7.62; 37 -4.597,-7.62; 38 -4.191,-7.62; 39 -3.81,-7.62; 40 -3.404,-7.62; 41 -2.997,-7.62; 42 -2.591,-7.62; 43 -2.21,-7.62; 44 -1.803,-7.62; 45 -1.397,-7.62; 46 -0.991,-7.62; 47 -0.61,-7.62; 48 -0.203,-7.62; 49 0.203,-7.62; 50 0.61,-7.62; 51 0.991,-7.62; 52 1.397,-7.62; 53 1.803,-7.62; 54 2.21,-7.62; 55 2.591,-7.62; 56 2.997,-7.62; 57 3.404,-7.62; 58 3.81,-7.62; 59 4.191,-7.62; 60 4.597,-7.62; 61 5.004,-7.62; 62 5.41,-7.62; 63 5.791,-7.62; 64 6.198,-7.62; 97 6.198,7.62; 98 5.791,7.62; 99 5.41,7.62; 100 5.004,7.62; 101 4.597,7.62; 102 4.191,7.62; 103 3.81,7.62; 104 3.404,7.62; 105 2.997,7.62; 106 2.591,7.62; 107 2.21,7.62; 108 1.803,7.62; 109 1.397,7.62; 110 0.991,7.62; 111 0.61,7.62; 112 0.203,7.62; 113 -0.203,7.62; 114 -0.61,7.62; 115 -0.991,7.62; 116 -1.397,7.62; 117 -1.803,7.62; 118 -2.21,7.62; 119 -2.591,7.62; 120 -2.997,7.62; 121 -3.404,7.62; 122 -3.81,7.62; 123 -4.191,7.62; 124 -4.597,7.62; 125 -5.004,7.62; 126 -5.41,7.62; 127 -5.791,7.62; 128 -6.198,7.62
DBZ3 = smd 0.559 x 1.321: 1 -0.94,-1.016; 2 0.94,-1.016 | smd 0.559 x 1.575: 3 0,0.889
DRY6 = smd 0.559 x 0.305: 1 -0.356,0.508 | smd 0.508 x 0.305: 2 -0.381,0; 3 -0.381,-0.508; 4 0.381,-0.508; 5 0.381,0; 6 0.381,0.508
ABLS = smd 5.588 x 2.108: 1 -4.826,0; 2 4.826,0

## Placement (x,y rotation side)
+1V2  DNP  [1,6/0,9]  38.48,47.88 0 top
+1V2_EMU  DNP  [1,6/0,9]  39.5,43.69 0 top
C1  33pF  [C0402K]  80.01,34.29 0 top
C2  33pF  [C0402K]  80.01,33.27 0 top
C3  1000pF  [C0402]  99.59,48.93 90 top
C4  10uF  [C0805K]  82.55,49.53 90 top
C5  0.1uF  [C0402K]  80.47,36.14 180 top
C6  0.1uF  [C0402K]  80.26,29.24 180 top
C7  0.1uF  [C0402K]  90.27,20.37 270 top
C8  10uF  [C0805K]  65.05,35.84 270 top
C9  0.1uF  [C0402K]  91.34,20.37 270 top
C10  0.1uF  [C0402K]  94.61,20.32 270 top
C11  0.1uF  [C0402K]  107.95,32.84 0 top
C12  0.1uF  [C0402K]  107.95,39.88 0 top
C13  0.1uF  [C0402K]  100.69,48.95 90 top
C14  0.1uF  [C0402K]  95.35,48.84 90 top
C15  0.1uF  [C0402K]  87.76,48.84 90 top
C16  0.1uF  [C0402K]  84.33,49.4 90 top
C17  0.1uF  [C0402K]  80.47,38.84 180 top
C18  0.1uF  [C0402K]  80.47,31.11 180 top
C19  0.1uF  [C0402K]  101.02,20.32 270 top
C20  0.1uF  [C0402K]  87.3,20.32 270 top
C21  0.1uF  [C0402K]  107.95,41.38 0 top
C22  0.1uF  [C0402K]  96.85,48.79 90 top
C23  0.1uF  [C0402K]  88.77,48.84 90 top
C24  4700pF  [C0402K]  110.38,28.19 90 top
C25  22uF  [C0805K]  26.67,29.08 90 top
C26  22uF  [C0805K]  23.5,28.7 90 top
C27  22uF  [C0805K]  22.99,32.64 0 top
C28  1uF  [C0402K]  18.8,37.97 90 top
C29  0.1uF  [C0402K]  34.37,45.67 90 top
C30  22uF  [C0805K]  23.24,42.04 0 top
C31  4700pF  [C0402K]  59.44,30.78 0 top
C32  22uF  [C0805K]  24.05,45.85 270 top
C33  22uF  [C0805K]  31.9,45.19 270 top
C34  33pF  [C0402K]  37.49,29.9 180 top
C35  0.1uF  [C0402K]  59.39,28.02 0 top
C36  0.1uF  [C0402K]  59.39,31.83 0 top
C37  0.1uF  [C0402K]  59.39,35.64 0 top
C38  0.1uF  [C0402K]  49.23,43.18 90 top
C39  33pF  [C0402K]  37.36,27.51 180 top
C40  0.1uF  [C0402K]  37.54,36.47 180 top
C41  0.1uF  [C0402K]  37.62,32.72 180 top
C42  0.1uF  [C0402K]  37.39,26.49 180 top
C43  0.1uF  [C0402K]  43.54,21.03 270 top
C44  0.1uF  [C0402K]  48.34,20.98 270 top
C45  0.1uF  [C0402K]  52.88,21.03 270 top
C46  10uF  [C0805K]  38.18,40.67 180 top
C47  0.1uF  [C0402K]  37.49,30.91 180 top
C48  0.1uF  [C0402K]  59.39,29.29 0 top
C49  0.1uF  [C0402K]  49.56,20.98 270 top
C50  10uF  [C0805K]  51.23,20.45 270 top
C51  4.7uF  [C0603K]  15.72,19.08 270 top
C52  0.1uF  [C0402K]  12.98,19.33 90 top
C53  4700pF  [C0402K]  2.54,12.06 180 top
C54  4700pF  [C0402K]  22.38,18.41 270 top
C55  100uF  [C1206K]  7.49,6.73 0 top
DRILEGEND  [DRILEGEND]  not placed on the board
FB1  23 OHM @ 100MHz  [FB_MJ4516]  8.26,22.86 0 top
FB2  23 OHM @ 100MHz  [FB_MJ4516]  8.26,13.97 0 top
FID1  DNP  [FIDUCIAL_1MM]  2.54,6.35 0 top
FID2  DNP  [FIDUCIAL_1MM]  3.17,60.96 0 top
FID3  DNP  [FIDUCIAL_1MM]  128.27,6.35 0 top
FID4  DNP  [FIDUCIAL_1MM]  80.86,21.9 0 top
FID5  DNP  [FIDUCIAL_1MM]  106.27,47.3 0 top
J1  DNP  [SAMTEC-FTR-110-51-S-D-06]  9.65,56.39 270 top
J2  [1X10]  35.56,10.79 0 top
J3  DNP* (PART OF 2X10)  [1X10]  35.56,13.34 0 top
J4  [1X10]  35.56,53.98 0 top
J5  DNP* (PART OF 2X10)  [1X10]  35.56,56.52 0 top
J6  DNP  [1X10]  99.06,10.79 0 top
J7  DNP  [1X10]  99.06,13.34 0 top
J8  DNP  [1X10]  99.06,53.98 0 top
J9  DNP  [1X10]  99.06,56.52 0 top
J10  DNP  [1X50_ALT]  66.04,65.41 0 top
J11  DNP  [1X50]  66.04,1.91 0 top
J12  DNP  [FTSH-105-01-F-DV]  9.14,28.45 270 top
J13  USB_MICRO_B_SMD  [USB_MICRO_B_SMD]  1.63,18.41 270 top
J14  DNP  [CUI_PJ002BH]  7.65,40.01 0 top
JP1  SHUNT_HANG_OFF  [JP1]  70.23,37.3 90 top
JP2  SHUNT_ON  [JP1]  17.14,10.79 270 top
JP3  SHUNT_ON  [JP1]  17.14,13.34 270 top
JP4  DNP  [JP1]  81.28,10.79 270 top
JP5  DNP  [JP1]  81.28,13.34 270 top
JP6  SHUNT_ON  [JP1]  6.99,9.53 270 top
L1  1uH  [L2520P]  20.95,29.46 90 top
L2  1uH  [L2520P]  21.34,44.83 90 top
LED1  RED  [CHIPLED_0603]  124.33,55.24 270 top
LED2  GRN  [CHIPLED_0603]  115.32,28.32 270 top
LED3  GRN  [CHIPLED_0603]  115.26,18.1 270 top
LED4  GRN  [CHIPLED_0603]  43.56,43.56 90 top
LED6  GRN  [CHIPLED_0603]  17.4,25.44 180 top
LED7  GRN  [CHIPLED_0603]  67.01,27.38 270 top
LED8  GRN  [CHIPLED_0603]  67.01,26.11 270 top
LED9  RED  [CHIPLED_0603]  13.46,6.58 90 top
MH1  DNP  [MH_94_200]  20.32,6.99 0 top
MH2  DNP  [MH_94_200]  120.65,60.33 0 top
MH3  DNP  [MH_94_200]  120.65,6.99 0 top
MH4  DNP  [MH_94_200]  20.32,60.33 0 top
PAD9  DNP  [2,54/1,1]  125.73,59.69 180 top
PAD10  DNP  [2,54/1,1]  2.54,29.84 180 top
PAD11  DNP  [2,54/1,1]  125.73,7.62 180 top
PAD12  DNP  [2,54/1,1]  11.94,9.65 0 top
PAD13  DNP  [SMD1,27-2,54]  10.16,19.05 270 bottom
PAD14  DNP  [SMD1,27-2,54]  7.62,16.51 270 bottom
PAD15  DNP  [SMD1,27-2,54]  5.08,19.05 270 bottom
PAD16  DNP  [SMD1,27-2,54]  5.08,21.59 270 bottom
PAD17  DNP  [SMD1,27-2,54]  10.16,16.51 270 bottom
Q1  TEMT6000  [TEMT6000]  116.42,61.99 90 top
R1  0  [R0402]  99.69,20.32 90 top
R2  0  [R0402]  98.42,20.32 270 top
R3  0  [R0402]  95.89,20.32 90 top
R4  DNP  [R0402]  97.16,20.32 90 top
R5  2.2k  [R0402]  80.26,26.85 0 top
R6  10.0K  [R0402]  17.14,53.98 0 top
R7  2.2k  [R0402]  123.7,53.09 0 top
R8  2.2k  [R0402]  123.7,51.82 180 top
R9  2.2k  [R0402]  123.7,50.55 0 top
R10  2.2k  [R0402]  123.7,49.28 0 top
R11  2.2k  [R0402]  124.33,56.52 0 top
R12  33  [R0402]  97.97,48.84 270 top
R13  2.2k  [R0402]  115.32,26.16 0 top
R14  5.76K  [R0402]  113.63,60.03 90 top
R15  2.2k  [R0402]  115.26,24.04 180 top
R16  2.2k  [R0402]  115.19,16 180 top
R17  2.2k  [R0402]  115.06,13.97 0 top
R18  31.6K  [R0402]  26.67,31.65 0 top
R19  10.0K  [R0402]  26.67,32.92 0 top
R21  4.99  [R0402]  18.8,34.54 90 top
R22  2.2k  [R0402]  43.56,42.04 0 top
R25  5.76K  [R0402]  27.18,42.85 180 top
R26  10.0K  [R0402]  27.18,41.63 180 top
R27  2.2k  [R0402]  16.26,32.47 0 top
R28  31.6K  [R0402]  37.92,39.07 180 top
R29  0.010  [R1206W]  28.07,47.02 180 top
R30  330K  [R0402]  59.44,25.7 180 top
R31  330K  [R0402]  54.31,21.03 90 top
R32  2.2k  [R0402]  64.47,27.38 0 top
R33  2.2k  [R0402]  64.47,26.11 0 top
R34  220K  [R0402]  59.44,24.46 0 top
R35  220K  [R0402]  55.58,21.03 270 top
R39  2.2k  [R0402]  37.47,35.36 0 top
R40  49.9  [R0402]  67.01,28.65 180 top
R41  2.2k  [R0402]  14.33,19.35 270 top
R42  2.2k  [R0402]  24.82,19.68 270 top
R43  220K  [R0402]  23.62,18.41 270 top
R44  1M  [R0402]  5.08,12.06 0 top
R45  62K  [R0402]  26.14,19.68 90 top
S1  TACT6MM_NO_MOM  [CK_PTS645_SMD]  121.92,45.72 0 top
S2  TACT6MM_NO_MOM  [CK_PTS645_SMD]  121.92,35.56 0 top
S3  TACT6MM_NO_MOM  [CK_PTS645_SMD]  121.92,25.4 0 top
S4  TACT6MM_NO_MOM  [CK_PTS645_SMD]  121.92,15.24 0 top
U1  RM46L850_PGE_144  [PGE144]  93.56,34.6 0 top
U2  TPS3106K33_DBV_6  [DBV6]  120.14,51.94 0 top
U5  LM26420XMHX/NOPB  [MXA20A]  23.53,37.35 90 top
U6  INA210_DCK_6  [DCK6]  36.91,45.69 0 top
U7  TM4C129ENCPDT  [PDT128]  48.59,31.86 180 top
U8  LM4040D30_DBZ_3  [DBZ3]  65.2,32.16 0 top
U9  TPS2553_DBV_6  [DBV6]  19.05,19.05 0 top
U10  TPD4E004_DRY_6  [DRY6]  7.82,18.47 0 top
Y1  16.00MHZ  [ABLS]  75.62,34.16 90 top
Y2  16.00MHZ  [ABLS]  32.55,28.69 90 top

## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via)
5V_USB_LIMITED  (via drill 0.38 pad 0.69)
  Top 0.152: v2.55,24.47 v13.77,24.47 | v4.24,9.53 v2.55,9.53
  Top 0.508: U9.6 21.06,19.99 21.46,20.19
  Top 0.762: 21.46,20.19 21.46,20.8 21.41,21.06 v20.09,21.06
  Bottom 0.152: v20.09,21.06 16.68,24.47 v13.77,24.47 | v2.55,9.53 v2.55,24.47 | v4.24,9.53 JP6.1
+1V2  (via drill 0.38 pad 0.56, 0.38 pad 0.69)
  Top 0.152: U1.57 94.84,23.88 | 102.06,32.85 v101.91,32.87 | U1.114 99.82,45.32 | U1.123 95.3,45.32 | C12.1 107.35,40.48 110.48,40.48 110.79,40.78 110.79,43.08 110.48,43.38 105.96,43.38 105.66,43.69 105.66,44.53 106.11,44.83 108.25,44.83 108.56,45.21 108.56,45.87 108.86,46.18 123.32,46.18 123.63,46.48 123.63,50.55 R9.2 | v49.39,27.2 52.93,27.2 54.38,26.05 U7.127 | 29.59,47.04 R29.1 | U1.137 88.31,47.33 88.27,47.37 88.01,47.37 87.76,47.62 C15.1 | v85.34,48.77 84.36,48.77 C16.1 | U1.143 85.31,43.72 v86.31,43.18 | U1.29 | v81.08,48.13 81.47,48.53 C4.1
  Top 0.178: C7.1 90.27,21.79 90.42,21.89 90.42,22.76 90.31,22.87 U1.48 90.32,23.88 | C9.1 91.34,21.79 90.83,22.15 U1.49 | C10.1 94.56,20.95 | C5.1 81.09,35.36 U1.17 85.32,35.36 v85.32,34.9 | C6.1 80.87,29.34 | U1.45 88.8,23.9
  Top 0.203: C13.1 100.69,47.7 100.43,47.45 100.43,47.17 99.82,46.41 99.82,45.33
  Top 0.229: v85.7,29.9 85.29,29.9 84.89,29.41 83.82,29.41 83.74,29.34 U1.29
  Top 0.254: 94.56,20.95 93.88,20.95 93.88,22.33 94.41,22.55 94.81,22.72 U1.57 | 88.8,23.9 v88.8,27.2 | 90.32,23.88 v90.32,26.82 | 94.84,23.88 v94.84,26.82 | 102.06,32.85 U1.87 C11.1 | v101.19,39.98 102.31,39.86 U1.101 104.3,39.88 C12.1 | 99.82,45.32 v99.82,43.13 | 95.3,45.32 v95.3,43.03 | U1.137 88.31,43.04 v87.76,42.57 | C15.1 87.73,48.22 | C14.1 arc90 95.3,48.19 95.3,47.3 95.05,47.04 95.05,46.63 95.3,46.38 95.3,45.34 U1.123 | 99.82,45.33 U1.114 | 80.87,29.34 U1.29 | U6.5 38.96,45.7 39.62,46.35 39.62,48.64 39.24,49.02 28.32,49.02 28.32,46.99 29.54,46.99 R29.1 | U1.49 90.82,26.05 91.44,26.67 91.44,26.72 v91.85,27.08
  Bottom 0.152: v50.15,48.31 50.14,47.55 49.76,47.17 49.76,37.03 49.99,36.8 49.99,35.28 49.38,34.67 49.38,28.19 49.39,27.5 v49.39,27.2
  other vias: 29.18,48.31 28.96,45.62 30.71,48.31 33.96,48.31 35.66,48.31 30.43,45.62 32.33,48.31
  pour Route15 (isolate 0.305): 24.77,49.53 24.77,46.35 27.28,46.41 27.33,45.03 38.1,45.09 38.1,47.62 81.28,47.62 81.28,45.09 81.92,44.45 81.94,43.84 84.84,41.33 84.84,25.86 102.41,25.86 102.41,43.61 91.14,43.71 91.11,41.81 88.57,41.78 88.39,41.78 88.34,43.79 85.19,43.79 83.19,45.72 83.19,46.74 85.09,46.74 85.09,49.53 30.53,49.94 29.16,51.31 25.15,51.31 25.1,51.36 25.1,49.86
  pour Top: 28.65,48.59 28.65,45.69 28.68,45.16 32.87,45.16 32.97,45.26 32.97,45.62 33.02,45.67 33.48,46.18 33.48,47.35 36.35,47.4 36.32,48.74 28.85,48.67
+1V2_EMU
  Top 0.152: R25.1 27.89,42.87 27.79,42.97 | 26.67,47.12 R29.2 | 39.45,45.03 39.45,43.74 +1V2_EMU.1
  Top 0.178: 27.79,42.97 27.79,43.59 26.54,44.48 26.54,45.09 26.57,45.11 R29.2 | R29.2
  Top 0.254: U6.4 39.45,45.03 40.13,45.72 40.13,48.77 39.5,49.53 28.19,49.53 27.81,49.4 27.81,47.12 27.69,46.99 26.59,46.99 R29.2
  pour Top: 27.2,45.97 27.2,48.18 26.49,48.9 17.63,48.9 17.58,44.83 22.73,44.83 22.73,45.97
+1V2_TM4C  (via drill 0.38 pad 0.69)
  Top 0.152: C47.1 38.52,30.79 38.76,30.53 38.91,30.38 38.91,29.77 39.42,29.27 U7.87 v48.29,29.27
  Top 0.178: C49.1 49.57,22.41 | 49.57,22.41 v49.58,22.91 U7.115 | C50.1 51.21,22.4 49.57,22.41
  Bottom 0.152: v49.58,22.91 48.29,24.2 v48.29,29.27
+3V3  (via drill 0.38 pad 0.56, 0.38 pad 0.69)
  Top 0.152: 96.83,46.29 U1.120 | 16.47,54 R6.1 16.47,53.95 15.93,53.95 15.85,54.03 v15.85,55.17 | U7.68 U7.69 | R40.1 v68.68,28.65 | J12.1 v4.88,30.99 | R18.2 27.38,31.64 v28.21,31.64 | U7.47 49.2,40.92 49.23,40.95 C38.1 v48.36,42.58 45.37,42.58 44.83,42.04 R22.2 | U7.16 57.44,31.65 v57.8,31.85 57.83,31.85 57.99,31.85 58.76,31.85 C36.1 | 57.4,28.04 U7.7 v54.93,28.05 | 57.4,28.04 58.06,28.04 58.09,28.02 C35.1 | U7.8 57.4,28.45 57.4,28.04 | R39.1 36.46,35.34 v35.84,35.33 | C42.1 38.43,26.64 38.71,26.92 38.71,27.64 38.86,27.84 v39.27,27.84 39.73,27.84 39.83,28.04 U7.90 | v122.2,53.66 122.22,53.63 122.22,52.88 U2.6 | v47.36,21.81 47.36,21.92 47.7,21.58 C44.1 | v80.68,30.25 80.68,31.11 C18.1 | v52.4,36.91 U7.39 | v57.49,35.67 U7.26 | v47.6,40.76 U7.51 | v52.4,25.52 U7.122 | 54.96,36.5 v54.7,36.76 55,36.45 U7.28 | v47.19,38.19 U7.52 | v122.69,55.24 LED1.A | v38.22,31.85 C41.1 | v58.78,34.77 C37.1 | v81.07,39.7 C17.1 | v107.35,42.24 C21.1 | v88.17,20.92 C20.1 | v43.56,22.62 C43.1 | v125.19,53.09 R7.2 | v95.89,18.82 R3.1 | R10.2 v125.19,49.28 127,51.08 127,57.02 127.38,57.4 127.38,61.85 126.9,62.33 122.99,62.33 122.07,63.25 117.42,63.25 116.42,62.24 Q1.3 | v96.84,47.09 v96.83,47.09 | C26.1 23.44,27.65 23.44,26.14 | C46.1 40.23,40.66 40.13,40.64 v40.39,40.64 | R13.2 v116.97,26.16 | R17.2 116.33,13.97 116.84,14.48 116.84,15.14 v117.32,15.62 | J1.5 4.85,59.56 v4.72,59.44 | C23.1 88.77,47.35 v89.05,47.07 | U1.136 88.81,46.83 v89.05,47.07 | U1.134 89.81,46.84 89.66,46.99 89.13,46.99 v89.05,47.07
  Top 0.178: C40.1 38.24,36.45 | 38.24,36.45 U7.69 | C43.1 43.54,22.61 43.99,22.91 U7.101 | C44.1 48.36,22.61 48.77,22.91 U7.113 | C45.1 52.88,22.66 52.38,22.96 U7.122 | R31.1 v54.3,19.43 | R35.2 v55.58,18.52 | C20.1 87.32,20.94 | 38.24,36.45 39.17,36.46 39.31,36.71 39.42,36.88 v39.42,37.08 | U7.90 | C41.1 39.67,32.72 39.93,32.46 U7.79 | U1.10 C17.1
  Top 0.254: 87.32,20.94 U1.42 | C18.1 81.03,30.99 81.79,30.99 81.79,30.84 U1.26 | C21.1 105.44,41.38 105.41,41.35 U1.104 | C22.1 v96.83,47.09 96.83,46.29 | U1.134
  Top 0.508: C8.1 65.13,36.92 v63.6,36.93
  Top 1.016: J11.3 9.22,2.23 9.22,3.4 10.9,5.08 15.04,5.08 16.13,6.1 16.13,9.37 15.88,10.06 JP2.1
  other vias: 18.34,28.09 20.42,25.96 19.2,27.03 22.07,25.91 24.16,25.91 25.04,27.99 26.01,25.91 28.3,28.24
  pour Route15 (isolate 0.305, rank 2): 130.18,66.67 0.64,66.67 0.64,0.64 130.18,0.64
  pour Top: 17.75,29.21 17.75,27.53 19.2,26.09 19.81,25.35 28.73,25.35 28.8,27.58 28.8,28.85 28.7,28.96 25.35,28.96 24.99,28.6 22.45,28.6 21.84,29.21
+5V  (via drill 0.38 pad 0.69)
  Top 0.152: R4.1 97.16,18.59 v97.38,18.59 | U5.18 21.95,40.23 21.95,41.4 22.25,41.71 22.25,41.86 22.55,41.55 22.55,40.18 | JP5.1 81,14.33 93.11,14.33 93.41,14.63 93.41,16 93.72,16.31 v96.7,16.31 | R27.2 17.38,32.47 R21.1 | 22.57,33.62 22.48,33.53 | 22.48,33.13 C27.1 | U5.2 21.25,33.74 | 21.46,33.16 C27.1 | 21.91,32.72 C27.1 | 35.91,45.07 U6.3
  Top 0.254: U5.4 22.57,33.62 | 22.48,33.53 22.48,33.13 | 21.25,33.74 21.34,33.66 21.46,33.66 21.46,33.16 | U5.3 21.91,32.72 | 35.91,45.07 C29.1 34.37,40.59 33.78,40.01 29.59,40.01 29.21,39.62 29.21,26.04 28.19,25.02 19.68,25.02 18.92,25.91 17.4,27.43 17.4,31.11 16.89,31.62 16.89,32.46 R27.2
  Top 0.762: 7.47,6.81 7.47,6.76 7.44,6.73 C55.1 7.37,6.76 7.47,6.81 | 7.47,8.43 7.47,8.74 8.23,9.5 | 8.23,9.5 JP6.2 | J14.1A J14.1B | 7.47,6.81 7.47,8.43 | 7.47,8.43 7.52,8.84 8.23,9.55 | 8.23,9.55 8.33,9.6 | 8.28,9.6 8.23,9.55 | 8.23,9.55 8.23,9.5
  Top 1.016: 77.62,4.06 32.77,4.12 32,3.91 28.3,3.91 21.59,10.46 21.59,13.61 20.52,14.88 16.41,14.88 15.9,14.58 JP3.1 | 77.62,4.06 v76.33,4.06 v77.83,4.06 | 77.62,4.06 | 77.62,4.06 v77.83,4.06 | v77.83,4.06 v79.48,4.06
  Bottom 0.152: v96.7,16.31 96.7,17.22 97.38,18.14 v97.38,18.59
  Bottom 1.016: v76.33,4.06 79.5,4.06 79.48,7.85 78.18,9.3 78.18,11.38 79.55,13.21 80.01,13.31 JP5.1 | JP3.1 15.85,13.31 8.23,13.36 8.23,9.5
  other vias: 16.38,41.85 16.38,40.26 16.38,38.76 16.38,37.26 16.38,35.69 16.38,34.04 9.14,46.93 7.62,46.93
  pour Top: 22.81,40.74 22.81,40.13 22.56,39.88 20.73,39.88 20.57,39.47 20.57,35.31 20.73,34.7 22.81,34.7 22.81,32.08 19.23,32 16.64,32 16.64,33.4 15.42,33.6 15.42,42.06 14.61,42.16 14.61,43.18 3.3,43.18 3.3,47.75 16,47.75 16,42.77 22.3,42.77 22.76,42.72 22.76,41.3
  pour Route15 (no thermals): 0.64,0.64 0.64,66.67 5.08,66.67 5.08,62.61 2.29,62.61 2.29,49.02 14.61,49.02 14.61,45.21 14.73,45.21 14.73,44.96 17.72,44.96 17.72,33.53 2.48,33.53 2.41,7.75 4.95,7.75 4.95,4.88 12.73,4.9 12.83,14.73 9.78,14.73 9.78,8 7.11,8 7.11,16.38 16.76,16.45 16.76,12.51 14.29,12.51 14.22,4.32 15.24,4.32 15.29,0.64
+5V_USB  (via drill 0.38 pad 0.69)
  Top 0.152: R30.1 R34.2 61.5,24.46 61.81,24.16 61.81,17.79 61.5,17.49 46.84,17.49 46.53,17.79 v46.53,19.35 | U7.96 39.58,25.66 38.41,24.13 v38.41,23.11 38.41,23.06
  Top 0.305: U10.5 9.04,18.47 v9.55,17.91
  Top 0.381: 17.95,21.44 U9.1 16.52,19.99 16.43,19.95 C51.1 | 23.01,21.97 v23.5,21.51 23.8,21.21 24.51,21.21 24.82,20.9 R42.1
  Top 0.406: 23.01,21.97 18.27,21.97 17.95,21.44 | C51.1 15.72,20 R41.1 14.33,20.88 10.13,20.88 FB1.2 10.11,22.86 10.11,19.86 10.77,19.2 11.53,19.2 12.01,18.8 12.01,17.45 11.33,16.92 10.27,16.92 9.76,17.43 9.76,17.7 v9.55,17.91
  Bottom 0.152: v23.5,21.51 23.7,21.51 25.3,23.11 v38.41,23.11 41.49,20.03 44.42,20.04 45.12,19.35 v46.53,19.35
  Bottom 0.305: PAD17.1 v9.55,17.91
AD1EVT/MII_RX_ER/RMII_RX_ER  (via drill 0.38 pad 0.69)
  Top 0.152: v106.06,31.98 105.71,32.34 U1.86
  Bottom 0.152: v106.06,31.98 107.95,33.87 J8.9 106.7,55.68 106.7,61.57 106.68,62.99 106.3,63.5 103.38,63.5 102.87,64.14 J10.40
AD1IN_0  (via drill 0.38 pad 0.69)
  Top 0.152: v96.31,26.37 U1.60 | v82.95,20.12 79.99,16.9 71.88,16.89 70.61,16.26 32.14,16.27 J3.3
  Bottom 0.152: v82.95,20.12 89.05,20.12 94.92,25.98 95.56,25.98 95.94,26.36 96.09,26.36 v96.31,26.37
AD1IN_1  (via drill 0.38 pad 0.69)
  Top 0.152: U1.71 101.82,22.63 101.92,22.53 101.92,17.53 101.16,16.76 v100.83,16.76
  Bottom 0.152: J6.6 101.32,11.79 101.32,16.27 v100.83,16.76
AD1IN_2  (via drill 0.38 pad 0.69)
  Top 0.152: v103.55,15.43 103.28,15.7 103.28,25.86 U1.73 | v100.62,15.24 95.56,15.24 95.25,14.86 J7.4
  Bottom 0.152: v103.55,15.43 102.23,15.43 101.93,15.73 101.93,18.92 101.73,19.13 100.66,19.13 100.36,18.82 100.36,18.52 99.97,18.14 99.97,15.85 100.58,15.24 v100.62,15.24
AD1IN_3  (via drill 0.38 pad 0.69)
  Top 0.152: v104.98,18.65 105.25,18.91 105.25,26.34 U1.74 | v97.12,6.26 98.82,6.26 99.12,5.95 99.12,3.76 99.68,3.33 115.95,3.3 116.33,3.2 v116.35,3.18
  Bottom 0.152: v116.35,3.18 116.35,18.34 116.05,18.65 v104.98,18.65 | J7.5 97.79,12.52 96.7,11.43 96.7,9.75 97.31,9.14 97.31,6.45 v97.12,6.26
AD1IN_4
  Top 0.152: U1.76 103.28,27.36 102.98,27.06 102.98,14.7 102.87,14.59 J7.7
AD1IN_5  (via drill 0.38 pad 0.69)
  Top 0.152: U1.78 106.15,28.35 v106.3,28.5
  Bottom 0.152: v106.3,28.5 108.02,27.7 110.23,27.7 110.41,27.89 117.73,27.89 118.19,28.35 118.25,28.35 118.52,28.62 118.57,57 117.81,57.76 117.81,62.03 119.63,63.86 120.64,63.86 120.65,63.87 J10.47
AD1IN_6  (via drill 0.38 pad 0.69)
  Top 0.152: U1.80 107.56,29.34 v107.81,28.94 108.8,27.59 C24.1 | Q1.1 115.84,58.52 114.68,58.52 114.33,58.17 v114.17,58.17 113.63,58.71 R14.1
  Bottom 0.152: v107.81,28.94 113.87,28.94 114.17,29.25 v114.17,58.17 114.17,66.09 114.48,66.4 122.2,66.4 J10.48
AD1IN_7  (via drill 0.38 pad 0.69)
  Top 0.152: v96.28,22.54 96.85,22.95 96.85,23.7 U1.61 | v94,5.25 98.28,5.25 98.59,4.94 98.59,3.75 98.28,3.44 86.67,3.44 84.1,5.99 49.78,5.99 49.48,6.3 44.81,6.3 44.45,5.99 34.1,5.99 34.09,6.01 30.48,9.31 30.48,12.06 J3.4
  Bottom 0.152: v94,5.25 94,22.08 94.54,22.84 95.54,22.84 96.01,22.78 v96.28,22.54
AD1IN_8/AD2IN_8  (via drill 0.38 pad 0.69)
  Top 0.152: v109.75,31.98 108.62,30.84 U1.83
  Bottom 0.152: v109.75,31.98 112.05,31.98 112.36,32.28 112.36,63.37 112.05,63.68 110.8,63.68 110.49,63.98 J10.43
AD1IN_9/AD2IN_9  (via drill 0.38 pad 0.69)
  Top 0.152: J6.2 90.17,8.75 90.32,8.53 90.48,8.46 92.28,8.46 92.51,8.23 93.57,8.23 93.8,8.46 98.94,8.45 98.95,8.45 v101.62,8.45 101.62,4.44 102.12,3.94 116.59,3.94 117.22,3.3 124.84,3.3 125.73,2.41 J11.49 | v101.04,18.29 101.61,18.71 101.61,21.81 101.58,21.85 101.58,22.4 101.36,22.7 101.35,22.7 101.31,22.73 U1.70
  Bottom 0.152: v101.62,8.45 101.62,17.25 101.19,17.68 101.19,18.14 v101.04,18.29
AD1IN_10/AD2IN_10
  Top 0.152: J11.50 126.12,4.06 117.6,4.06 116.84,4.83 104.39,4.83 103.71,4.95 103.28,5.63 103.28,8.71 102.97,9.02 94.31,9.02 94,9.32 94,12.04 J7.3 93.7,13.34 94,13.64 94,15.28 94.31,15.58 94.64,15.62 97.84,15.62 98.15,15.93 101.88,15.93 102.3,16.34 U1.72
AD1IN_11/AD2IN_11  (via drill 0.38 pad 0.69)
  Top 0.152: 106.16,24.1 105.86,23.79 105.86,18.12 104.41,16.67 104.41,9.93 104.11,9.63 99.36,9.63 99.06,9.93 99.06,12.06 J7.6 | 106.16,24.1 105.86,24.4 105.86,26.55 105.55,26.85 U1.75 | 106.16,24.1 v109,24.1
  Bottom 0.152: v109,24.1 127.97,24.1 128.27,24.4 J10.50
AD1IN_12/AD2IN_12  (via drill 0.38 pad 0.69)
  Top 0.152: J7.8 106.68,14.61 106.68,20.12 v110.27,23.26 110.27,25.6 108.5,26.89 106.97,26.89 105.81,27.84 U1.77
  Bottom 0.152: v110.27,23.26 129.38,23.26 129.68,23.56 129.68,66.09 129.38,66.4 126.72,66.4 J10.49
AD1IN_13/AD2IN_13  (via drill 0.38 pad 0.69)
  Top 0.152: v101.27,35.23 101.27,29.16 101.58,28.86 U1.79 | v116.73,49.53 106.68,49.53 104.66,49.53 v104.51,49.68
  Bottom 0.152: v101.27,35.23 103.9,35.23 104.39,35.72 104.39,47.47 104.09,47.85 104.09,49.26 v104.51,49.68 | v116.73,49.53 116.73,65.1 117.03,65.41 J10.46
AD1IN_14/AD2IN_14  (via drill 0.38 pad 0.69)
  Top 0.152: v109.68,30.36 U1.82
  Bottom 0.152: v109.68,30.36 112.72,30.36 113.03,30.66 J10.44
AD1IN_15/AD2IN_15  (via drill 0.38 pad 0.69)
  Top 0.152: v103.05,31.86 U1.85 | v109.67,42.81 v105.82,42.81 | v109.67,45.26 126.92,45.26 127.36,45.56 127.38,56.52 128.14,58.04 128.14,62.99 126.92,64.14 116.71,64.14 116.33,64.39 106.41,64.4 J10.41
  Bottom 0.152: v105.82,42.81 105.16,42.15 105.16,32.16 104.86,31.86 v103.05,31.86 | v109.67,45.26 v109.67,42.81
AD1IN_16/AD2IN_0  (via drill 0.38 pad 0.69)
  Top 0.152: J11.41 104.22,0.71 28.25,0.71 27.94,1.02 27.94,2.54 v26.67,3.43 | v95.47,25.11 95.32,24.96 U1.58 | v106.4,5.52 v106.4,7.27
  Bottom 0.152: v106.4,7.27 106.4,16.28 106.1,16.58 103.08,16.58 102.78,16.89 102.78,22.65 102.47,22.96 97.62,22.96 v95.47,25.11 | J11.41 106.4,2.9 v106.4,5.52 | v26.67,3.43 J2.2
AD1IN_17/AD2IN_1  (via drill 0.38 pad 0.69)
  Top 0.152: v98.78,7.72 98.3,7.24 95.7,7.24 95.59,7.34 95.47,7.47 37.64,7.47 36.83,8.28 J2.6 | 95.86,23.77 U1.59 95.78,23.84 95.78,22.94 94.83,21.99 v94.83,21.97 | v98.56,14.59 v95.82,14.59
  Bottom 0.152: J11.42 107.95,5.79 107.64,6.09 99.96,6.09 v98.78,7.72 98.78,14.37 v98.56,14.59 | v95.82,14.59 95.21,15.2 95.21,21.2 v94.83,21.97
AD1IN_18/AD2IN_2  (via drill 0.38 pad 0.69)
  Top 0.152: U1.62 v97.32,25.11 97.32,26.89 96.93,27.28 96.93,27.96 96.24,28.73 88.24,28.73 87.96,28.45 85.67,26.54 84.15,26.54 83.81,26.1 83.81,17 83.38,16.19 83.06,16 76.96,16 76.07,15.24 53.72,15.24 53.34,15.62 35.43,15.62 34.72,15.43 34.29,14.87 J3.5
  Bottom 0.152: J11.43 109.22,3.17 109.22,16.87 108.92,17.18 103.7,17.18 103.4,17.48 103.4,22.96 103.09,23.26 98.89,23.26 97.84,24.31 97.84,24.6 v97.32,25.11
AD1IN_19/AD2IN_3  (via drill 0.38 pad 0.69)
  Top 0.152: v96.58,7.88 89.15,7.87 88.39,8.38 61.85,8.38 61.59,8.13 60.45,8.13 60.07,8.38 57.78,8.38 38.53,8.38 38.1,8.82 38.1,12.06 J3.6 | v97.58,21.82 U1.63
  Bottom 0.152: J11.44 111.84,0.71 96.89,0.71 96.58,1.02 96.55,5.03 96.55,5.18 96.24,5.49 96.24,7.53 v96.58,7.88 96.39,8.07 96.39,13.41 96.62,13.64 96.62,15.39 95.94,16.08 95.94,17.45 96.62,18.06 96.58,20.59 97.81,21.82 v97.58,21.82
AD1IN_20/AD2IN_4  (via drill 0.38 pad 0.56, 0.38 pad 0.69)
  Top 0.152: v52.2,14.61 76.33,14.61 77.23,15.51 83.81,15.51 84.12,15.81 84.12,25.84 84.43,26.16 85.93,26.16 88.37,28.14 95.49,28.14 v95.91,27.95 | U1.64 98.31,26.27 v98.02,26.56
  Bottom 0.152: J11.45 115.57,17.48 115.27,17.78 104.36,17.78 104.06,18.08 104.06,23.26 103.75,23.57 99.72,23.57 99.72,23.59 98.31,24.99 98.31,26.27 v98.02,26.56 97.26,26.56 96.77,27.05 96.77,27.09 v95.91,27.95 | J3.7 39.37,15.24 39.62,15.49 51.05,15.49 51.94,14.61 v52.2,14.61
AD1IN_21/AD2IN_5  (via drill 0.38 pad 0.69)
  Top 0.152: v98.07,16.88 93.41,16.88 93.11,16.57 93.11,14.94 92.8,14.76 79.25,14.73 78.11,13.08 50.42,13.08 49.02,14.48 43.31,14.48 J3.8 | v113.44,8.45 v104.15,8.45 | v98.96,22.39 98.82,22.48 U1.65
  Bottom 0.152: 98.73,19.52 98.66,19.45 98.07,18.86 v98.07,16.88 | 98.73,19.52 101.93,19.52 102.23,19.21 102.23,16.31 102.54,16 103.85,16 104.15,15.7 v104.15,8.45 | v113.44,8.45 114.3,7.59 114.3,1.02 114.61,0.71 116.92,0.71 J11.46 | v98.96,22.39 98.96,19.75 98.73,19.52
AD1IN_22/AD2IN_6  (via drill 0.38 pad 0.69)
  Top 0.152: v109.16,28.27 109.16,29.55 108.85,29.85 U1.81
  Bottom 0.152: v109.16,28.27 114.17,28.27 114.68,28.78 114.68,48.77 115.57,49.66 J10.45
AD1IN_23/AD2IN_7  (via drill 0.38 pad 0.69)
  Top 0.152: v108.04,31.41 107.98,31.35 U1.84
  Bottom 0.152: v108.04,31.41 108.52,30.93 112.36,30.93 112.66,31.23 112.66,64.2 111.76,65.1 111.76,66.09 111.45,66.4 108.94,66.4 J10.42
ADREFHI  (via drill 0.38 pad 0.69)
  Top 0.152: v99.53,26.41 99.29,25.83 99.29,23.9 arc90 U1.66 99.31,22.92 99.59,22.63 99.59,22.1 99.21,21.64 98.53,21.64 98.45,21.57 98.45,21 R2.1
  Bottom 0.152: v99.53,26.41 100.39,26.41 100.51,26.29 114.27,26.26 114.57,25.95 114.57,24.97 114.27,24.67 108.54,24.67 108.23,24.36 108.23,22.03 108.54,21.73 123.88,21.73 124.18,21.42 124.18,1.02 123.88,0.71 121.84,0.71 J11.47
ADREFLO  (via drill 0.38 pad 0.69)
  Top 0.152: v100.55,25.3 100.06,25.3 99.83,25 99.83,24.82 99.81,24.63 U1.67 99.82,23.87 99.82,22.94 99.97,22.78 99.97,22.17 99.69,21.59 R1.2
  Bottom 0.152: v100.55,25.3 101.16,24.42 101.46,24.12 105.09,24.12 108.35,20.86 | 108.35,20.86 | 108.35,20.86 122.89,20.86 123.19,20.4 123.14,9.45 123.6,8.99 123.6,5.18 123.19,4.78 J11.48
DCAN1RX  (via drill 0.38 pad 0.56, 0.38 pad 0.69)
  Top 0.152: v108.64,34.35 U1.90 | v104.14,64.26 99.06,64.26 J10.38
  Bottom 0.152: v108.64,34.35 111.48,34.35 111.78,34.65 111.86,52.12 111.86,62.65 111.78,62.73 111.25,63.12 110.36,63.12 109.47,64.14 109.35,64.26 v104.14,64.26
DCAN1TX  (via drill 0.38 pad 0.69)
  Top 0.152: v103.05,33.84 U1.89
  Bottom 0.152: v103.05,33.84 104.38,33.84 104.68,34.14 104.68,35.49 104.85,35.66 104.85,43.74 105.47,44.36 105.47,51.88 105.46,51.88 105.46,52.35 105.16,52.65 101.5,52.65 101.32,52.83 101.32,64.41 J10.39
DCAN2RX  (via drill 0.38 pad 0.69)
  Top 0.152: v92.32,47.51 U1.129 | v81.84,55.83 64.63,55.83 63.44,56.77 63.44,59.26 63,59.69 32.31,59.69 31.75,60.25 J10.12
  Bottom 0.152: v81.84,55.83 81.84,53.64 82.07,53.42 82.07,48.21 82.38,47.91 82.39,47.91 82.55,47.75 89.81,47.75 90.63,46.94 91.44,46.94 92.01,47.51 v92.32,47.51 92.18,47.37
DCAN2TX  (via drill 0.38 pad 0.69)
  Top 0.152: v90.51,49.23 92.59,49.23 92.89,48.92 92.89,46.66 92.8,46.57 U1.128 | v83.24,56.66 67.67,56.66 66.42,57.91 66.42,59.56 64.64,61.34 57.15,61.34 56.9,61.59 56.13,61.59 56.01,61.47 38.99,61.47 37.97,62.48 35.56,62.48 34.42,63.63 34.42,65.28 J10.13
  Bottom 0.152: v83.24,56.66 83.24,55.52 83.36,55.4 83.39,50.8 86.1,50.8 87.38,49.53 90.21,49.53 v90.51,49.23
DCAN3RX  (via drill 0.38 pad 0.69)
  Top 0.152: v79.62,37.58 79.88,37.85 U1.12
  Bottom 0.152: v79.62,37.58 79.62,35.67 79.31,35.37 62.71,35.37 61.38,34.04 54.5,34.04 54.2,33.74 54.2,22.02 54.88,21.34 54.88,16.12 54.57,15.81 35.59,15.81 35.28,15.51 35.28,2.9 J11.13
DCAN3TX  (via drill 0.38 pad 0.69)
  Top 0.152: v85.49,37.04 84.73,37.04 84.43,37.34 U1.13
  Bottom 0.152: v85.49,37.04 85.49,36.64 84.66,35.81 84.65,34.2 84.34,33.9 67.53,33.9 66.32,32.68 59.97,32.68 59.66,32.37 59.66,8.99 59.36,8.68 48.56,8.68 48.26,8.38 48.26,1.02 47.95,0.71 40.56,0.71 J11.15
ECLK1
  Top 0.254: R12.2 97.97,47.17 97.33,46.53 97.33,45.33 U1.119
ECLK1T  (via drill 0.38 pad 0.69)
  Top 0.152: v97.97,50.34 R12.1 | v89.41,59.52 72.46,59.52 72.42,59.56 70.74,59.56 68.33,61.98 68.33,63.63 67.73,64.25 50.68,64.25 J10.19
  Bottom 0.152: v97.97,50.34 97.45,50.86 97.45,51.2 96.83,51.82 94.64,51.82 94.03,52.43 94.03,56.69 94,56.72 94,57.35 93.7,57.66 90.78,57.66 89.48,58.95 v89.41,59.52
EXTERNAL_DEBUG  (via drill 0.38 pad 0.69)
  Top 0.152: v18.75,54 17.82,54 R6.2 17.75,54.02 17.75,54.71 17.37,55.09 17.37,55.63 14.71,58.29 J1.8 | U7.41 51.59,44.18 51.28,44.48 42.67,44.45 41.27,44.45 41.15,44.32 41.15,43.14 v40.59,42.58
  Bottom 0.152: v18.75,54 19.66,53.42 19.66,51.28 18.75,50.06 18.75,46.61 19.3,45.72 26.29,45.72 27.05,44.96 30.79,44.96 31.04,45.21 40.39,45.21 40.89,44.83 40.89,42.93 v40.59,42.58
GIOA_0  (via drill 0.38 pad 0.69)
  Top 0.152: v78.73,43.57 79.44,42.85 U1.2 | J4.10 48.16,53.95 48.46,54.1 52.5,54.1 52.81,53.95 54.63,53.95 54.75,53.98 55.09,54.32 v74.86,54.32
  Bottom 0.152: J4.10 45.72,55.24 45.72,57.2 46.02,57.51 47.9,57.51 48.51,56.9 50.34,56.9 50.59,56.64 50.59,51.64 51.03,51.12 51.05,47.17 51.05,46.63 50.83,46.41 50.83,37.8 50.67,37.64 50.67,34.37 50.22,33.91 50.22,28.96 50.44,28.73 51.05,28.19 51.05,20.61 50.72,20.28 49.24,20.28 48.93,19.98 48.93,18.78 48.63,18.48 22.85,18.48 22.61,18.23 22.61,16.76 22.35,16.51 21.59,16.51 20.57,15.49 20.57,10.67 20.42,10.52 19.66,10.52 17.53,8.38 17.53,3.43 J11.7 | v74.86,54.32 74.86,43.87 75.17,43.57 v78.73,43.57
GIOA_1  (via drill 0.38 pad 0.69)
  Top 0.152: v55.4,38.97 v70.15,38.97 | v49.37,35.55 49.76,35.59 51.82,35.59 v52.06,35.48 | U1.5 78.07,41.36 76.67,42.8 71.77,42.8 71.23,42.27 71.23,40.09 71.63,39.7 72.1,39.7 v72.83,38.97
  Bottom 0.152: v72.83,38.97 v70.15,38.97 | v55.4,38.97 54.06,38.97 53.76,38.66 53.76,37.48 v52.06,35.48 51.78,35.5 51.78,17.02 51.47,16.72 28.25,16.72 27.94,16.41 27.94,3.17 J11.10 | v49.37,35.55 49.37,49.06 J4.9
GIOA_2/N2HET2_0/EQEP2I  (via drill 0.38 pad 0.69)
  Top 0.152: v31.7,4.98 46.57,4.98 v46.87,5.28 | v52.67,34.03 v43.81,34.03 | v57.49,42.75 v55.19,42.75 | v58.06,33.32 58.06,36.95 v57.49,37.52 | v85.53,39.35 U1.9
  Bottom 0.152: v46.87,5.28 46.92,8.68 47.22,8.99 56.86,8.99 57.16,9.29 57.16,32.41 v58.06,33.32 63.87,33.32 64.17,33.62 64.17,34.57 64.48,34.88 79.61,34.88 83.59,39.32 85.53,39.32 v85.53,39.35 | v31.7,4.98 J11.12 | v43.81,34.03 43.81,49.77 43.51,50.07 42.22,50.07 41.91,50.38 J4.8 | v55.19,42.75 55.19,40.09 56.29,38.99 56.29,38.4 55.99,38.09 54.37,38.09 54.06,37.79 54.06,35.3 53.76,34.99 53.33,34.99 v52.67,34.03 | v57.49,37.52 v57.49,42.75
GIOA_5/EXTCLKIN/EPWM1A  (via drill 0.38 pad 0.69)
  Top 0.152: v51.26,53.4 50.64,53.4 50.15,52.91 40.44,52.91 J4.7 | v72.48,42 72.52,42.04 73.94,42.04 74.19,42.29 76.61,42.29 76.9,42 78.19,40.56 78.19,37.42 78.58,36.86 U1.14 | v54.72,46.11 61.87,46.1 62.29,46.56 62.59,46.85 v72.48,46.85
  Bottom 0.152: J11.16 40.62,3.2 35.89,3.2 35.59,2.9 35.59,1.02 35.28,0.71 25.72,0.71 25.42,1.02 25.42,16.87 25.72,17.18 48.39,17.18 51.36,20.15 51.36,46.41 51.51,46.56 51.51,51.44 51.36,51.59 51.36,52.5 51.51,52.65 51.51,53.15 v51.26,53.4 51.26,55.46 51.64,55.84 53.45,55.84 53.76,55.54 53.76,46.69 v54.72,46.11 | v72.48,46.85 v72.48,42
GIOA_6/N2HET2_4/EPWM1B  (via drill 0.38 pad 0.56, 0.38 pad 0.69)
  Top 0.152: v77.29,12.08 43.19,12.08 J2.8 41.91,9.65 42.16,9.4 43.81,9.4 v44.07,9.14 | v86.46,35.93 86.08,36.35 85.11,36.35 84.92,36.16 84.61,35.84 U1.16
  Bottom 0.152: v86.46,35.93 86.39,35.99 86.41,35.59 86.39,28.25 85.69,27.41 85.69,23.01 85.13,22.58 78.92,22.58 78.61,22.27 78.64,14.07 78.64,13.87 v77.29,12.08 | J11.18 44.07,4.83 v44.07,9.14
GIOA_7/N2HET2_6/EPWM2A  (via drill 0.38 pad 0.69)
  Top 0.152: v71.82,32.37 71.82,25.85 72.07,25.52 76.85,25.52 77.2,25.88 77.2,31.86 77.51,32.16 81.39,32.16 81.7,32.47 81.7,32.85 U1.22 | J11.19 48.27,3.17 34.75,3.15 33.51,3.15 v33.22,2.81
  Bottom 0.152: v71.82,32.37 60.27,32.37 59.97,32.07 59.97,8.18 59.66,7.88 53.4,7.88 49.53,4 J11.19 | v33.22,2.81 34.29,4.83 J2.5
GIOB_0  (via drill 0.38 pad 0.69)
  Top 0.152: U1.126 93.82,46.88 v93.88,46.94 93.7,47.12 93.7,50.81 94.09,51.21 98.75,51.21 99.36,51.82 103.48,51.82 103.63,51.66 103.63,51.44 104.08,50.98 105.11,50.98 105.41,51.29 J8.8 | J10.15 41.25,63.52 49.73,63.52 49.84,63.63 66.9,63.63 v67.23,63.45 | v84.48,51.41 83.82,51.44 83.69,51.56 80.61,51.56 80.23,51.1 80.23,49.98 79.69,49.21 77.75,49.21 v77.11,50.17
  Bottom 0.152: v77.11,50.17 77.11,62.21 76.71,62.61 68.07,62.61 v67.23,63.45 | v84.48,51.41 89.31,51.41 92.58,48.13 92.71,48.13 93.09,47.75 93.09,47.12 93.7,47.12 v93.88,46.94 93.7,47.12
GIOB_1  (via drill 0.38 pad 0.69)
  Top 0.152: v107.1,44.03 107.07,44.03 107.14,43.97 115.78,43.96 116.08,43.65 116.08,35.06 116.08,34.54 114.57,33.03 LED2.A | v104.14,58.34 104.17,58.67 103.71,59.05 96.7,59.05 96.24,58.6 96.24,52.76 95.78,52.3 93.85,52.3 93.57,52.58 91.44,52.58 v91.16,52.3 89.94,50.77 89.94,47.22 90.3,46.86 90.3,45.34 U1.133 | J10.8 22.87,64.13 28.05,64.13 28.36,63.82 28.36,59.56 28.66,59.26 62.53,59.26 62.83,58.95 62.83,56.64 63.52,55.83 64.26,55.37 80.64,55.37 80.9,55.24 84.07,55.24 84.29,55.31 v84.68,55.31
  Bottom 0.152: v107.1,44.03 106.08,44.91 106.08,52.49 106.45,53.03 106.45,54.48 106.07,55.02 105.84,55.24 104.14,55.24 | 104.14,55.24 v104.14,58.34 | v91.16,52.3 91.16,54.97 90.78,55.35 84.87,55.35 v84.68,55.31 | J8.7 104.14,55.24
GIOB_2  (via drill 0.38 pad 0.69)
  Top 0.152: v63.32,46.28 81.41,46.23 82.19,47.09 83.72,47.09 84.07,47.5 84.71,47.5 85.09,47.12 85.09,46.86 85.82,46.13 U1.142 85.85,45.28 85.85,44.32 86.06,44.12 86.94,44.12 87.12,43.79 87.12,42.01 89.31,40.06 94.72,40.06 95.25,40.9 v95.75,40.9 | J5.10 48.01,56.46 59.28,56.46 v60.19,56.97 | v102.07,25.46 102,27.44 101.69,27.75 99.5,27.75 98.3,28.96 96.62,28.96 95.75,29.83 v95.75,34.27 | v112.76,25.46 112.76,20.55 112.52,20.16 112.52,19.56 113.98,18.1 LED3.A 114.76,18.1 | v45.54,20.57 45.54,17.49 45.24,17.18 25.43,17.18 24.55,16.31 v23.39,16.31 | J11.5 14.99,3.3 v22.23,3.3
  Bottom 0.152: v60.19,56.97 60.19,58.95 60.49,59.26 63.01,59.26 63.32,58.95 v63.32,46.28 | v95.75,34.27 v95.75,40.9 | v112.76,25.46 v102.07,25.46 | J5.10 48.52,54.99 48.52,51.58 50.72,49.38 | 50.72,49.38 | 50.72,49.38 50.72,47.14 50.22,46.63 50.22,37.11 50.29,37.03 50.29,34.9 49.84,34.44 49.84,28.35 50.67,27.51 50.72,21.18 50.42,20.79 46.33,20.8 45.94,20.57 v45.54,20.57 | v23.39,16.31 22.91,16.31 22.61,16 21.72,16 21.08,15.37 21.08,10.79 23.52,8.36 23.52,4.6 v22.23,3.3
GIOB_3  (via drill 0.38 pad 0.69)
  Top 0.152: J5.4 32.99,55.35 35.26,55.35 35.56,55.58 35.56,57.2 35.87,57.51 52.8,57.51 53.22,57.09 v57.51,57.09 | v57.51,44.25 59.11,44.25 59.31,44.45 60.2,44.45 60.33,44.32 79.12,44.32 79.88,43.56 81.41,43.56 81.66,43.31 82.82,43.31 U1.1
  Bottom 0.152: J5.4 31.75,62.4 31.45,62.7 24.62,62.7 23.32,64.01 20.88,64.01 20.42,64.47 20.42,65.99 20.02,66.4 1.18,66.4 0.88,66.09 0.88,4.47 1.18,4.17 14.24,4.17 J11.6 | v57.51,57.09 v57.51,44.25
GND  (via drill 0.38 pad 0.56, 0.38 pad 0.69)
  Top 0.152: U1.21 84.09,33.35 v84.12,33.33 | U1.11 84.12,38.36 v84.28,38.35 | C40.2 v35.87,36.47 | U7.80 39.78,32.06 v39.5,31.9 | C44.2 48.34,19.23 v48.36,19.2 | R34.1 58.04,24.46 v57.91,24.43 | J12.7 J12.9 v4.88,25.91 | J12.7 J12.5 | J12.5 J12.3 v4.88,29.72 | J12.5 v4.88,28.45 | J12.7 7.11,27.13 v4.88,27.13 | C28.2 18.85,38.62 | C25.2 26.29,29.7 C26.2 | U5.14 24.54,40.23 24.54,41.3 24.24,41.6 C30.2 24.24,41.46 23.88,41.1 23.88,40.2 U5.15 | C38.2 49.23,43.84 48.21,43.84 v48.16,43.89 | C35.2 60.78,28.02 v60.96,28.04 | C36.2 60.98,31.83 v61.01,31.8 | C31.2 v61.06,30.79 | C48.2 60.88,29.29 v60.96,29.31 | U7.66 42.58,37.65 v42.67,37.64 | C34.2 36.04,29.9 v35.81,29.82 | C39.2 36.04,27.51 v35.76,27.58 | C47.2 35.84,30.91 v35.81,30.94 | C42.2 35.84,26.49 v35.46,26.01 | PAD9.1 125.73,54.59 126.07,54.25 126.07,52.12 125.77,51.82 R8.1 | v44.78,38.19 U7.58 | v54.93,32.06 U7.17 | v54.93,29.27 U7.10 | v48.79,38.19 U7.48 | v46,40.76 U7.55 | v116.67,47.97 S1.1 | v117.79,51.94 U2.2 | v125.89,46.83 S1.2 | v125.89,36.66 S2.2 S2.1 | S3.2 v125.89,28.8 125.95,28.85 | v49.55,19.42 C49.2 | v79.61,25.9 R5.1 | v59.98,34.77 C37.2 | v113.31,16 R16.2 | C24.2 110.38,29.86 110.49,29.97 110.5,32.35 v110.03,32.82 | C46.2 36.3,40.66 v35.94,40.64 | LED6.C 17.4,24.77 16.38,24.77 16.13,25.02 16.13,29.97 14.35,31.75 14.35,33.5 v13.54,34.31 | R15.2 114.61,24.82 114.81,25.02 v116.59,25.02 117.6,25.02 117.98,25.4 117.98,27.61 S3.1 | S4.1 S4.2 | S4.2 125.98,17.4 | S4.2 125.86,17.53 | v125.86,18.8 125.95,18.76 125.95,17.67 125.88,17.6 S4.2 | R14.2 114.71,60.68 v114.76,60.73 | J1.20 v14.4,50.67 | J1.4 14.53,60.83 v14.55,60.81 | J1.10 14.43,57.02 v14.48,57.07 | J1.12 14.38,55.75 v14.4,55.78
  Top 0.152: J1.16 14.5,53.21 v14.55,53.26 | U8.2 65.41,31.14 v65.28,31.11 | U7.62 43.18,40.77 | 43.18,40.77 42.24,40.77 v42.22,40.79 41.91,41.1 41.91,43.05 42.42,43.56 LED4.C | 24.38,33.04 C27.2 | U7.61 43.59,40.77 43.18,40.77 | 35.85,46.27 U6.1 | C29.2 34.2,46.27 | 33.4,44.32 33.27,44.2 31.91,44.2 C33.2 | U1.138 87.83,46.67 v87.38,47.12 | 82.48,50.6 C4.2 81.4,50.53 v81.03,50.9 | v85.34,50.16 84.49,50.16 C16.2 | U1.144 84.83,46.62 v84.45,46.86 | 100.99,19.7 99.72,19.7 R1.1 | U1.68 100.32,22.22 v100.55,21.99 | LED8.C v68.68,26.11 | LED7.C v68.68,27.38
  Top 0.178: C4.2 82.25,50.34 | U7.114 49.23,25.15 49.23,25.3 49,25.53 v49,25.76 | C50.2 51.21,18.54 v51.21,18.09 | C45.2 v52.88,19.41 | R35.1 55.55,22.4 55.24,22.71 v55.19,22.71 | C43.2 v43.54,19.36 | C20.2 87.38,19.64 | C10.2 94.64,19.7 | C19.2 100.99,19.7 | R1.1 99.72,19.64 | U7.64 42.39,40.62 v42.22,40.79 | C41.2 35.87,32.72 v35.81,32.77
  Top 0.203: U1.115 99.31,46.74 v99.57,47.07
  Top 0.254: C7.2 v90.27,18.75 | C9.2 v91.34,18.75 | 87.38,19.64 v87.38,18.75 | 94.64,19.7 v94.64,18.75 | 99.72,19.64 v99.72,18.82 | C17.2 v78.79,38.84 78.66,38.84 | C5.2 78.77,36.14 v78.74,36.12 | C18.2 78.72,31.11 v78.69,31.14 | C6.2 78.82,29.23 v78.69,29.36 | C11.2 110.01,32.84 v110.03,32.82 | C12.2 v109.86,39.88 | C21.2 v109.83,41.38 109.91,41.38 | U1.27 83.98,30.36 v84.15,30.07 | U1.28 81.76,29.85 v81.58,30.07 | U1.50 91.3,25.24 v91.87,25.68 | U1.56 94.33,25.76 v93.78,26.31 | U1.88 105.69,33.35 v105.92,33.48 | U1.102 106.13,40.34 v106.27,40.54 | U1.103 v102.34,40.84 | U1.115 | U1.121 v96.32,43.03 | U1.122 95.81,45.34 v95.81,46.84 | C15.2 87.76,50.55 v87.78,50.55 | C23.2 arc-90 88.75,49.47 v88.75,50.55 | C14.2 v95.35,50.55 | C22.2 96.85,50.47 v96.88,50.49 | C3.2 99.59,50.53 v99.57,50.55 | C13.2 v100.69,50.55 | v89.32,43.38 U1.135 | U5.7 24.5,33.64 24.38,33.53 24.38,33.04 | U6.2 U6.1 | C29.2 35.85,46.27 | 34.2,46.27 33.66,45.72 33.66,45.34 33.4,45.09 33.4,44.32 | U1.47 89.81,21.99 v89.31,21.49 | U1.44 88.31,22.65 v88.14,22.48 87.83,22.79 U1.43
  Top 0.305: U5.20 20.57,40.23 v19.86,40.23 | 18.85,38.62 v19.76,38.61 | C26.2 23.67,29.88 23.67,30.99 23.93,31.24 23.93,31.6 23.99,31.66 C27.2 23.86,32.76 U5.6
  Top 0.381: C52.2 v12.06,19.94 | U9.2 v16.69,19.07 16.69,18.38 16.38,18.21 C51.2 | v21.46,17.86 C54.2 23.57,17.82 R43.2
  Top 0.406: v10.11,11.73 10.13,11.76 FB2.2 10.13,15.32 9.96,15.49 v9.35,15.49 v10.87,15.49
  Top 0.508: C8.2 65.01,34.8 v63.6,34.8
  Top 0.762: v13.54,34.31 J14.3 v8.91,34.31 v7.42,34.31 J14.2 v2.97,34.31
  Top 1.016: C55.2 10.41,6.73 11.18,7.49 11.18,8.89 PAD12.1
  other vias: 22,38.35 22,37.34 22,36.32 23.01,38.35 23.01,37.34 23.01,36.32 24.03,38.35 25.04,38.35 24.03,37.34 24.03,36.32 25.04,36.32 25.04,37.34 27.58,40.03 25.63,43.56 25.55,42.21 25.63,44.91 33.17,41.1 10.67,6.99 26.57,38.35 26.57,37.34 26.57,36.32 27.58,38.35 27.58,37.34 27.58,36.32
  pour Top (rank 2): 23.11,30.99 23.11,30.02 23.67,29.46 27.33,29.46 28.8,30.53 28.73,37.57 28.24,38.05 28.24,39.65 28.73,40.26 28.88,40.54 33.68,40.54 33.68,44.68 30.63,44.75 28.09,45.92 22.96,45.87 22.96,43.13 23.27,42.82 23.27,41.35 23.57,41.05 25.45,41.05 25.45,39.27 21.03,39.22 20.98,39.17 20.98,35.86 21.39,35.46 21.39,35.41 24.89,35.41 24.94,35.36 24.94,32.77
  pour Route2 (isolate 0.305): 130.18,66.67 0.64,66.67 0.64,0.64 130.18,0.64
  pour Bottom: 4.45,25.53 12.83,25.53 12.83,26.92 30.4,26.9 30.43,26.92 30.43,35.99 31.78,37.34 34.14,37.34 37.08,37.29 37.11,44.02 18.16,43.94 18.29,49.02 2.54,49.02 2.54,33.27 4.45,33.27
HERCULES_ICORE
  Top 0.152: U7.15 57.61,31.24 58.01,30.79 C31.1
  Top 0.254: U7.15 43.55,31.25 43.24,31.55 43.18,31.62 43.18,34.8 43.37,34.99 43.37,37.97 42.94,38.4 41.99,38.4 41.4,38.99 40.44,38.99 40.37,39.06 R28.1
HERCULES_LIN1_RXD  (via drill 0.38 pad 0.56, 0.38 pad 0.69)
  Top 0.152: v88.3,38.67 88.3,39.2 87.36,39.92 84.37,39.92 83.94,40.48 83.94,43.67 82.52,44.96 56.9,44.96 56.64,44.7 56.64,43.81 56.9,43.56 58.42,43.56 58.79,43.19 58.79,42.1 | v60.85,58.69 60.03,58.69 59.89,58.83 26.98,58.83 26.67,59.22 v26.67,63.27 | 58.79,42.1 54.69,42.1 54.38,41.8 U7.34 | v60.85,42.03 59.09,42.03 58.79,42.1 | U1.131 91.3,42.38 91.14,42.22 91.14,41.68 91.59,41.22 92.56,41.22 v92.99,40.79 | v92.91,36.14 92.91,36.04 88.54,36.04 88.43,36.07 v88.3,36.2
  Bottom 0.152: v88.3,38.67 v88.3,36.2 88.3,27.62 88.14,27.46 88.14,25.91 87.38,25.15 87.38,23.83 87.43,23.77 87.43,21.28 87.12,20.98 82.42,20.98 82.12,20.67 82.12,19.62 82.42,19.32 93.4,19.32 93.7,19.01 93.7,11.79 J6.3 | v26.67,63.27 J10.10 | v60.85,42.03 v60.85,58.69 | v92.91,36.14 v92.99,40.79
HERCULES_LIN1_TXD  (via drill 0.38 pad 0.69)
  Top 0.152: U7.33 54.79,40.84 55.09,41.15 v58.09,41.15 v69.54,41.15 | v76.47,9.45 80.97,9.45 81.28,9.76 81.28,11.76 81.58,12.06 91.14,12.06 91.44,11.76 91.44,9.58 91.9,8.9 v93.2,8.9 | v91.13,31.5 86.67,28.32 v85.56,28.32 | v90.75,40.9 90.83,41.29 90.83,44.73 U1.132